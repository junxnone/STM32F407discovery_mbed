# Keil uVision project Nucleo_printf.uvproj, settings and files
target mbed NUCLEO_F411RE (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Nucleo_printf
  c flags: Optim=1
  c define: STM32F4XX, HSE_VALUE=8000000
  c misc: --gnu
  c include: ..\mbed\api;..\mbed\common;..\mbed\hal;..\mbed\targets\cmsis;..\mbed\targets\hal\TARGET_STM\TARGET_STM32F4XX;..\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4XX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\mbed\targets\cmsis\TARGET_STM\TARGET_STM32F4XX\TOOLCHAIN_ARM_STD\STM32F407.sct
  group core
    ../mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4XX/TOOLCHAIN_ARM_STD/: startup_STM32F40x.s sys.cpp
  group User
    ./: main.cpp
  group common
    ../mbed/common/: assert.c board.c BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp error.c Ethernet.cpp exit.c FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp gpio.c I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_interface.c pinmap_common.c RawSerial.cpp retarget.cpp rtc_time.c semihost_api.c Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp us_ticker_api.c wait_api.c
  group targets\cmsis
    ../mbed/targets/cmsis/: core_ca_mmu.h core_ca9.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../mbed/targets/cmsis/TARGET_STM/TARGET_STM32F4XX/: cmsis_nvic.c system_stm32f4xx.c
  group targets\hal
    ../mbed/targets/hal/TARGET_STM/TARGET_STM32F4XX/: analogin_api.c device.h gpio_api.c gpio_object.h i2c_api.c objects.h PeripheralNames.h pinmap.c PinNames.h port_api.c PortNames.h spi_api.c us_ticker.c
  group hal
    ../mbed/hal/: analogin_api.h analogout_api.h can_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h us_ticker_api.h
